# IAR project dual_core.ewp, settings and files
configuration USB (ARM, debug)
  General.OGChipSelectEditMenu: GD32A490xK GD GD32A490xK
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32A490; USE_USB_FS; USE_USB_HS; USE_ULPI_PHY
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\Firmware\CMSIS\GD\GD32A490\Include; ..\..\..\..\..\Firmware\GD32A490_standard_peripheral\Include; ..\..\..\..\..\Firmware\GD32A490_usb_library\device\class\cdc\Include; ..\..\..\..\..\Utilities; ..\..\..\..\..\Firmware\GD32A490_usb_library\device\core\Include; ..\..\..\..\..\Firmware\GD32A490_usb_library\driver\Include; ..\..\..\..\..\Firmware\GD32A490_usb_library\ustd\common; ..\..\..\..\..\Firmware\GD32A490_usb_library\ustd\class\cdc; ..\..\..\..\..\Firmware\GD32A490_usb_library\device\class\hid\Include; ..\..\..\..\..\Firmware\GD32A490_usb_library\ustd\class\hid
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: dual_core.srec
  ILINK.IlinkOutputFile: dual_core.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../src/: app.c custom_hid_itf.c gd32a490_hw.c gd32a490_it.c
  group CMSIS
    ../src/: system_gd32a490.c
  group Doc
    ../: readme.txt
  group GD32A490_EVAL
    ../../../../../Utilities/: gd32a490i_eval.c
  group GD32A490_Peripherals
    ../../../../../Firmware/GD32A490_standard_peripheral/Source/: gd32a490_ctc.c gd32a490_dma.c gd32a490_exti.c gd32a490_gpio.c gd32a490_misc.c gd32a490_pmu.c gd32a490_rcu.c gd32a490_spi.c gd32a490_syscfg.c gd32a490_timer.c gd32a490_usart.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32A490/Source/IAR/: startup_gd32a490.s
  group USB_Class
    ../../../../../Firmware/GD32A490_usb_library/device/class/cdc/Source/: cdc_acm_core.c
    ../../../../../Firmware/GD32A490_usb_library/device/class/hid/Source/: custom_hid_core.c
  group USB_Device
    ../../../../../Firmware/GD32A490_usb_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Drivers
    ../../../../../Firmware/GD32A490_usb_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
