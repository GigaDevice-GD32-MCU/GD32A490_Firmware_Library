# Keil uVision project msc_cdrom.uvproj, settings and files
target USBFS_msc_cdrom (ARM-ADS)
  device: GD32A490IK GigaDevice
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x08000000-0x082FFFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: USBFS_msc_cdrom +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: GD32A490,USE_USB_FS
  c misc: --c99
  c include: ..\inc;..\..\..\..\..\Firmware\CMSIS\GD\GD32A490\Include;..\..\..\..\..\Firmware\GD32A490_standard_peripheral\Include;..\..\..\..\..\Firmware\GD32A490_usb_library\device\class\msc\Include;..\..\..\..\..\Firmware\GD32A490_usb_library\device\core\Include;..\..\..\..\..\Firmware\GD32A490_usb_library\driver\Include;..\..\..\..\..\Firmware\GD32A490_usb_library\ustd\common;..\..\..\..\..\Firmware\GD32A490_usb_library\ustd\class\msc;..\..\..\..\..\Utilities
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ../src/: app.c flash_data.c flash_msd.c gd32a490_hw.c gd32a490_it.c usbd_storage_msd.c
  group CMSIS
    ../src/: system_gd32a490.c
  group GD32A490_EVAL
    ../../../../../Utilities/: gd32a490i_eval.c
  group GD32A490_Peripherals
    ../../../../../Firmware/GD32A490_standard_peripheral/Source/: gd32a490_exti.c gd32a490_gpio.c gd32a490_misc.c gd32a490_pmu.c gd32a490_rcu.c gd32a490_syscfg.c gd32a490_timer.c gd32a490_usart.c gd32a490_dma.c gd32a490_spi.c gd32a490_ctc.c gd32a490_fmc.c
  group USB_Drivers
    ../../../../../Firmware/GD32A490_usb_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
  group USB_Device
    ../../../../../Firmware/GD32A490_usb_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Class
    ../../../../../Firmware/GD32A490_usb_library/device/class/msc/Source/: usbd_msc_bbb.c usbd_msc_core.c usbd_msc_scsi.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32A490/Source/ARM/: startup_gd32a490.s
  group Doc
    ../: readme.txt
target USBHS_msc_cdrom (ARM-ADS)
  device: GD32A490IK GigaDevice
  cpu: as above
  output: USBHS_msc_cdrom +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: GD32A490,USE_USB_HS,USE_ULPI_PHY
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
