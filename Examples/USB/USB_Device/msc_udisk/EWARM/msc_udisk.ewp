# IAR project msc_udisk.ewp, settings and files
configuration USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32A490xK GD GD32A490xK
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32A490; USE_USB_FS
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\Firmware\CMSIS\GD\GD32A490\Include; ..\..\..\..\..\Firmware\GD32A490_standard_peripheral\Include; ..\..\..\..\..\Firmware\GD32A490_usb_library\device\class\msc\Include; ..\..\..\..\..\Utilities; ..\..\..\..\..\Firmware\GD32A490_usb_library\device\core\Include; ..\..\..\..\..\Firmware\GD32A490_usb_library\driver\Include; ..\..\..\..\..\Firmware\GD32A490_usb_library\ustd\common; ..\..\..\..\..\Firmware\GD32A490_usb_library\ustd\class\msc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: audio.srec
  ILINK.IlinkOutputFile: USBFS_msc_udisk.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration USBHS (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USB_HS; USE_ULPI_PHY; GD32A490
  OBJCOPY.OOCOutputFile: msc_udisk.srec
  ILINK.IlinkOutputFile: USBHS_msc_udisk.out
  group Application
    ../src/: app.c gd32a490_hw.c gd32a490_it.c sram_msd.c usbd_storage_msd.c
  group CMSIS
    ../src/: system_gd32a490.c
  group Doc
    ../: readme.txt
  group GD32A490_EVAL
    ../../../../../Utilities/: gd32a490i_eval.c
  group GD32A490_Peripherals
    ../../../../../Firmware/GD32A490_standard_peripheral/Source/: gd32a490_ctc.c gd32a490_dma.c gd32a490_exti.c gd32a490_gpio.c gd32a490_misc.c gd32a490_pmu.c gd32a490_rcu.c gd32a490_spi.c gd32a490_syscfg.c gd32a490_timer.c gd32a490_usart.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32A490/Source/IAR/: startup_gd32a490.s
  group USB_Class
    ../../../../../Firmware/GD32A490_usb_library/device/class/msc/Source/: usbd_msc_bbb.c usbd_msc_core.c usbd_msc_scsi.c
  group USB_Device
    ../../../../../Firmware/GD32A490_usb_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Drivers
    ../../../../../Firmware/GD32A490_usb_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
