# IAR project usbh_msc.ewp, settings and files
configuration USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32A490xK GD GD32A490xK
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USB_FS; GD32A490
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\Utilities; ..\..\..\..\..\Firmware\CMSIS\GD\GD32A490\Include; ..\..\..\..\..\Firmware\GD32A490_standard_peripheral\Include; ..\..\..\..\..\Firmware\GD32A490_usb_library\ustd\common; ..\..\..\..\..\Firmware\GD32A490_usb_library\host\core\Include; ..\..\..\..\..\Firmware\GD32A490_usb_library\host\class\msc\Include; ..\..\..\..\..\Firmware\GD32A490_usb_library\ustd\class\msc; ..\..\..\..\..\Utilities\LCD_common; ..\..\..\..\..\Firmware\GD32A490_usb_library\driver\Include; ..\..\..\..\..\Utilities\Third_Party\fat_fs\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBH_HID.srec
  ILINK.IlinkOutputFile: USBFS_usbh_msc.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration USBHS (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USB_HS; USE_ULPI_PHY; GD32A490
  ILINK.IlinkOutputFile: USBHS_usbh_msc.out
  group Application
    ../src/: gd32a490_it.c gd32a490_usb_hw.c main.c usbh_usr.c
  group CMSIS
    ../src/: system_gd32a490.c
  group Doc
    ../: readme.txt
  group FAT_FS
    ../../../../../Utilities/Third_Party/fat_fs/src/: ff.c ffunicode.c
  group GD32A490_EVAL
    ../../../../../Utilities/: gd32a490i_eval.c gd32a490i_eval_exmc_sdram.c gd32a490i_lcd_eval.c
    ../../../../../Utilities/LCD_common/: lcd_font.c lcd_log.c
  group GD32A490_Peripherals
    ../../../../../Firmware/GD32A490_standard_peripheral/Source/: gd32a490_dma.c gd32a490_exmc.c gd32a490_exti.c gd32a490_fmc.c gd32a490_gpio.c gd32a490_misc.c gd32a490_pmu.c gd32a490_rcu.c gd32a490_syscfg.c gd32a490_timer.c gd32a490_tli.c gd32a490_usart.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32A490/Source/IAR/: startup_gd32a490.s
  group USB_Class
    ../../../../../Firmware/GD32A490_usb_library/host/class/msc/Source/: usbh_msc_bbb.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
  group USB_Driver
    ../../../../../Firmware/GD32A490_usb_library/driver/Source/: drv_usb_core.c drv_usb_host.c drv_usbh_int.c
  group USB_Host
    ../../../../../Firmware/GD32A490_usb_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
