# Keil uVision project usbh_msc.uvprojx, settings and files
target USBFS_usbh_msc (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32A490IK GigaDevice
  pack: GigaDevice.GD32A490_DFP.1.0.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0300000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: USBFS_usbh_msc +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32A490,USE_USB_FS
  c include: ..\inc;..\..\..\..\..\Firmware\CMSIS\GD\GD32A490\Include;..\..\..\..\..\Firmware\GD32A490_standard_peripheral\Include;..\..\..\..\..\Firmware\GD32A490_usb_library\driver\Include;..\..\..\..\..\Firmware\GD32A490_usb_library\ustd\common;..\..\..\..\..\Firmware\GD32A490_usb_library\host\core\Include;..\..\..\..\..\Firmware\GD32A490_usb_library\host\class\msc\Include;..\..\..\..\..\Firmware\GD32A490_usb_library\ustd\class\msc;..\..\..\..\..\Utilities\LCD_common;..\..\..\..\..\Utilities\Third_Party\fat_fs\inc;..\..\..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ../src/: main.c usbh_usr.c gd32a490_it.c gd32a490_usb_hw.c
  group CMSIS
    ../src/: system_gd32a490.c
  group GD32A490_Peripherals
    ../../../../../Firmware/GD32A490_standard_peripheral/Source/: gd32a490_dma.c gd32a490_exmc.c gd32a490_exti.c gd32a490_fmc.c gd32a490_gpio.c gd32a490_misc.c gd32a490_rcu.c gd32a490_sdio.c gd32a490_syscfg.c gd32a490_usart.c gd32a490_timer.c gd32a490_tli.c gd32a490_pmu.c
  group GD32A490_EVAL
    ../../../../../Utilities/: gd32a490i_eval.c gd32a490i_lcd_eval.c gd32a490i_eval_exmc_sdram.c
    ../../../../../Utilities/LCD_common/: lcd_font.c lcd_log.c
  group USB_Driver
    ../../../../../Firmware/GD32A490_usb_library/driver/Source/: drv_usb_core.c drv_usb_host.c drv_usbh_int.c
  group USB_Host
    ../../../../../Firmware/GD32A490_usb_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
  group USB_Class
    ../../../../../Firmware/GD32A490_usb_library/host/class/msc/Source/: usbh_msc_bbb.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32A490/Source/ARM/: startup_gd32a490.s
  group FAT_FS
    ../../../../../Utilities/Third_Party/fat_fs/src/: ff.c ffunicode.c
  group Doc
    ../: readme.txt
target USBHS_usbh_msc (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32A490IK GigaDevice
  pack: GigaDevice.GD32A490_DFP.1.0.0
  cpu: as above
  output: USBHS_usbh_msc +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32A490,USE_USB_HS,USE_ULPI_PHY
  c include: ..\inc;..\..\..\..\..\Firmware\CMSIS\GD\GD32A490\Include;..\..\..\..\..\Firmware\GD32A490_standard_peripheral\Include;..\..\..\..\..\Firmware\GD32A490_usb_driver\Include;..\..\..\..\..\Firmware\GD32A490_usb_library\driver\Include;..\..\..\..\..\Firmware\GD32A490_usb_library\host\core\Include;..\..\..\..\..\Firmware\GD32A490_usb_library\ustd\common;..\..\..\..\..\Firmware\GD32A490_usb_library\host\class\msc\Include;..\..\..\..\..\Firmware\GD32A490_usb_library\ustd\class\msc;..\..\..\..\..\Utilities\Third_Party\fat_fs\inc;..\..\..\..\..\Utilities\LCD_common;..\..\..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 5.3.0
