# IAR project Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32A490xK GD GD32A490xK
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32A490
  ICCARM.CCIncludePath2: ..; ..\..\Firmware\GD32A490_standard_peripheral\Include; ..\..\Firmware\CMSIS; ..\..\Firmware\CMSIS\GD\GD32A490\Include; ..\..\Firmware\CMSIS\GD; ..\..\Utilities
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../: gd32a490_it.c main.c systick.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32A490/Source/: system_gd32a490.c
  group Doc
    ../: readme.txt
  group GD32A490_EVAL
    ../../Utilities/: gd32a490i_eval.c
  group GD32A490_Peripherals
    ../../Firmware/GD32A490_standard_peripheral/Source/: gd32a490_adc.c gd32a490_can.c gd32a490_crc.c gd32a490_ctc.c gd32a490_dac.c gd32a490_dbg.c gd32a490_dci.c gd32a490_dma.c gd32a490_enet.c gd32a490_exmc.c gd32a490_exti.c gd32a490_fmc.c gd32a490_fwdgt.c gd32a490_gpio.c gd32a490_i2c.c gd32a490_ipa.c gd32a490_iref.c gd32a490_misc.c gd32a490_pmu.c gd32a490_rcu.c gd32a490_rtc.c gd32a490_sdio.c gd32a490_spi.c gd32a490_syscfg.c gd32a490_timer.c gd32a490_tli.c gd32a490_trng.c gd32a490_usart.c gd32a490_wwdgt.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32A490/Source/IAR/: startup_gd32a490.s
