# Keil uVision project Project.uvproj, settings and files
target GD32A490 (ARM-ADS)
  device: GD32A490IK GigaDevice
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x08000000-0x082FFFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Project +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: GD32A490
  c include: ..\..\Utilities;..\..\Firmware\CMSIS;..\..\Template;..\..\Firmware\CMSIS\GD\GD32A490\Source\ARM;..\..\Firmware\GD32A490_standard_peripheral\Include;..\..\Firmware\CMSIS\GD\GD32A490\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ../: main.c systick.c gd32a490_it.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32A490/Source/: system_gd32a490.c
  group Peripherals
    ../../Firmware/GD32A490_standard_peripheral/Source/: gd32a490_adc.c gd32a490_can.c gd32a490_crc.c gd32a490_ctc.c gd32a490_dac.c gd32a490_dbg.c gd32a490_dci.c gd32a490_dma.c gd32a490_enet.c gd32a490_exmc.c gd32a490_exti.c gd32a490_fmc.c gd32a490_fwdgt.c gd32a490_gpio.c gd32a490_i2c.c gd32a490_ipa.c gd32a490_iref.c gd32a490_misc.c gd32a490_pmu.c gd32a490_rcu.c gd32a490_rtc.c gd32a490_sdio.c gd32a490_spi.c gd32a490_syscfg.c gd32a490_timer.c gd32a490_tli.c gd32a490_trng.c gd32a490_usart.c gd32a490_wwdgt.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32A490/Source/ARM/: startup_gd32a490.s
  group Utilities
    ../../Utilities/: gd32a490i_eval.c
  group Doc
    ../: readme.txt
